<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Cpp_Firmware_STM32F103C8.ewp</path>
    </project>
    <batchBuild />
</workspace>
