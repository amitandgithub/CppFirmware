# IAR project Cpp_Firmware_STM32F103C8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: CMSIS_Startup; STM32F10x_StdPeriph_Driver\inc; HAL\inc; App\Inc; Library\inc; Test\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ./: main.cpp
  group HAL/Gpio
    HAL/src/: GpioInput.cpp GpioOutput.cpp
  group HAL/I2C
    HAL/src/: I2CDriver.cpp
  group HAL/Peripheral
    HAL/src/: ClockManager.cpp InterruptManager.cpp Peripheral.cpp
  group HAL/SPI
    HAL/src/: SpiDriver.cpp
  group HAL/SysTick
    HAL/src/: SysTickTimer.cpp
  group Modules/Button
    HAL/src/: HwButton.cpp HwButtonIntr.cpp
  group Modules/Clock
    HAL/src/: Clock.cpp
  group Modules/DS3231
    HAL/src/: DS3231.cpp
  group Modules/INA219
    HAL/src/: INA219.cpp
  group Modules/LED
    HAL/src/: Led.cpp
  group Modules/Nokia 5110 Display
    HAL/src/: Nokia5110LCD.cpp
  group Modules/Time
    HAL/src/: MilliTime.cpp Time.cpp
  group Modules/UI
    HAL/src/: ControlScreen.cpp Screen.cpp UI.cpp
  group Startup
    CMSIS_Startup/: startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group Test
    Test/src/: Test.cpp
